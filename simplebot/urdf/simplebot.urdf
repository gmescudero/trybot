Commit message: small improvements

File: simplebot/urdf/simplebot.urdf (robot description, URDF)
Before this commit: robot simplebot, 3 links, 2 joints
Links:
- link base: mass 0.10 -> 10
