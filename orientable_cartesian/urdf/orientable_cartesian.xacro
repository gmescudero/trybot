Commit message: demo controll for 6dof cartesian

File: orientable_cartesian/urdf/orientable_cartesian.xacro (robot description, xacro)
@@ -122,4 +122,5 @@
   	</visual>
     <collision>
+      <origin xyz="0 0 0.1" rpy="0 0 0" />
       <geometry>
         <cylinder radius="0.05" length="0.1" />
